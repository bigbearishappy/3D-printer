# Keil uVision project BBear_Petty.uvproj, settings and files
target BBear_Petty (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BBear_Petty
  c flags: Optim=1
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\source_code\Marlin;.\source_code\configuration;.\source_code\language;.\source_code\motion_control\source_code;.\source_code\pin;.\source_code\servo;.\source_code\temperature\source_code;.\source_code\ULTRA_LCD;.\source_code\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./source_code/Marlin/: Marlin_main.c system_stm32f10x.c
  group Temperature
    ./source_code/temperature/source_code/: temperature.c
  group Motion_control
    ./source_code/motion_control/source_code/: Planner.c Stepper.c
  group Ultralcd
    ./source_code/ULTRA_LCD/: Ultralcd.c
  group Configuration
    ./source_code/configuration/: ConfigurationStore.c
  group BSP
    ./source_code/BSP/: USART.c TIM.c BSP.c
  group Lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Readme
    ./doc/: Readme.txt
